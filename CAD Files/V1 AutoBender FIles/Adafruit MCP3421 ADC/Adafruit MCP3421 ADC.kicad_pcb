# Repository neuralengatberkeley/Strain-Sensor-

File README.md:

# Strain-Sensor-

# ABS Filmanent LM Channels:

3D printed ABS channels to be dissolved in acetone:  

CAD file for 3d prints shown in image above:  ...CAD Files/abs_lofted_insert/basic strain gauge 0p02.ipt

3D printer used -> Original Prusa MK4s

# Strain Sensor Fabrication Procedure:

#  Auto Bender:

All Structural parts (e.g. plates, shaft collars, fasteners) were purchased from goBILDA:  https://www.gobilda.com/

# AutoBender Sensor Circuit:

# AutoBender PCB (which inlcudes sensor circuit and servo circuit):

AutoBender PCB design can be found here in ...Fritzing Files/Voltage Divider PCB/bender PCB.fzz

# Interpreting CSV Data File Columns:

Column A:  Disregard.  It was initially meant to provide the theoretical bend angle, but it is wrong and not used in any calculation.

Column B:  Adafruit BNO055 IMU Pitch Euler Angle (degrees)

Column C:  ADC Value as read from Adafruit Sensor MCP3421 18-Bit ADC (The ADC sensor is in parrallel with the Liquid Metal Strain Gauge (LMSG).  The LMSG is in series 			with a 100 ohm resistor).  Since the code is set to read 14-bits, the possible range of values is from 0 to 2^14 - 1.

Column D:  ADC Value as read from Hall Effect Rotary Encoder (https://p3america.com/erc-series/?srsltid=AfmBOoqSsWeZSXtsMrmoHyB0DRfSCzyFlUfcnEff0gpcv0NyMvrGhVz7).  The 		rotary encoder can rotate from 0 to 320 degrees.  There is a mechanical stop at 0 and 320 degrees.  Since the rotary encoder is connected directly to 			Arduino Uno, the adc output from the Arduino can have values from 0 to 2^10 - 1.  

Note about converting rotary encoder adc value to angle in degrees:  

As a result of this calculation, the rotatry encoder angle should always start at 0 degrees.  The initial IMU angle in degrees typically starts around ~ 3 degrees.  

# Derivation of Change in Resistance Formula as a Function of Axial Strain:

If an axial load is applied to a solid in the x-direction, the solid's lateral dimensions in the y- and z-directions will typically contract, depending on the material properties. The ratio of lateral contraction (negative strain) to axial extension (positive strain) is called Poisson's ratio. The definition includes a negative sign, ensuring that Poisson's ratio is a positive value for materials that contract laterally when stretched axially. 

References:  

1. Soft Robotics Toolkit. (n.d.). Casting soft robots. Retrieved January 14, 2025, 
	from https://softroboticstoolkit.com/book/export/html/206021
2. Craig Jr., R. R. (2011). Mechanics of materials (3rd ed.). Wiley.
3. Hambley, A.R. (2011). Electrical Engineering Principles and Applications (5th ed.).  Prentice Hall.
4. Callister Jr., W. D., & Rethwisch, D. G.  Materials Science and Engineering: An Introduction (10th ed.).  Wiley.
5. Chen, J., Zhang, J., Luo, Z., Zhang, J., Li, L., Su, Y., Gao, X., Li, Y., Tang, W., Cao, C., Liu, Q., Wang, L., & Li, H. (2020). 
	Superelastic, sensitive, and low hysteresis flexible strain sensor based on wave-patterned liquid metal for 
	human activity monitoring. ACS Applied Materials & Interfaces, 12(19), 22200–22211. 
	https://doi.org/10.1021/acsami.0c04709

# Explanation of Model Developed for Axial Strain as a Function of Bend Angle:

The finger joints are modeled as a hinged joint where the leaf rotation axis is concentric with the knuckle axis.  Additionally, the interial surface of the leaf is in contact with the exterior surface of the knuckle.  The change in length of the sample is calculated from the arc length forumla. This model is presented in the image below:

However, in our autobender, the interior rotating surface of the leaf is offset from the exterior surface of the knuckle by an amount delta.  The adjusted AutoBender model is presented in the image below:  

# Expected Trend for Normalized Resistance vs Axial Strain:

The plot below shows theoretical curves of normalized resistance versus axial strain for samples with varying lengths L, but identical liquid metal channel length (Lo) and cross-sectional area (A). The following trends are observed:

1.  As sample length, L, increases (assuming same liquid metal channel lengths and cross-sectional area), the slope of the curve decreases.
2.  A longer sample will experience less axial strain at a 90 degree bend angle
3.  For axial strains below approximately 40% (e.g., in human knuckle models), the relationship can be approximated as linear.
4.  As bend radius (R in this case, not r as indicated in human knuckle model image :/) increases, axial strain also increases for the same bend angle. For example, a strain sensor on a larger knuckle would experience greater axial strain compared to one on a smaller knuckle.  

# "Gluing" LMSG on to fingers:

"paint" Derma-Tac (https://www.smooth-on.com/products/derma-tac/) AND Skin-Tite (https://www.smooth-on.com/products/skin-tite/) onto finger, place sensor on finger for a couple minutes until cross-linking occurs

## KiCad design CAD Files/V1 AutoBender FIles/Adafruit MCP3421 ADC/Adafruit MCP3421 ADC.kicad_pcb

Parts:
C3: 10uF; 0805-NO
C4: 0.1uF; 0603-NO
CONN3, CONN4: STEMMA_I2C_QT; JST_SH4
D1: GREEN; CHIPLED_0603_NOOUTLINE
FB1: FERRITE; 0603-NO
FID3, FID4: FIDUCIAL_1MM
JP1: HEADER-1X670MIL; 1X06_ROUND_70
R1: 10K Pack; RESPACK_4X0603
U$9: MCP3421; SOT23-6
U$20, U$21, U$25, U$27: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
X1: 3.5mm Terminal Block; TERMBLOCK_1X2-3.5MM

Connections:
GND: C3.2, C4.2, CONN3.1 (GND), CONN3.MT1 (MT), CONN3.MT2 (MT), CONN4.1 (GND), CONN4.MT1 (MT), CONN4.MT2 (MT), D1.C, JP1.2, R1.1, R1.8 (2), U$9.2 (GND)
unnamed: D1.A, R1.5 (2)
SCL: CONN3.4 (SCL), CONN4.4 (SCL), JP1.3, R1.3 (1), U$9.3 (SCL)
SDA: CONN3.3 (SDA), CONN4.3 (SDA), JP1.4, R1.2 (1), U$9.4 (SDA)
VCC: C3.1, CONN3.2 (V+), CONN4.2 (V+), FB1.2, JP1.1, R1.4 (1), R1.6 (2), R1.7 (2)
VDD: C4.1, FB1.1, U$9.5 (VDD)
VIN+: JP1.5, U$9.1 (VIN+), X1.1
VIN-: JP1.6, U$9.6 (VIN-), X1.2

Notes on the sheet:
ON LED
STEMMA/I2C Headers
Power supply

Board: 2 copper layers, 25.4 x 17.8 mm, 37 parts (9 on the bottom side), 8 nets.

Other parts of the board:
PLABEL0: PLABEL0
PLABEL1: PLABEL1
PLABEL2: PLABEL2
PLABEL3: PLABEL3
PLABEL4: PLABEL4
PLABEL5: PLABEL5
PLABEL6: PLABEL6
PLABEL7: PLABEL7
PLABEL8: PLABEL8
PLABEL9: PLABEL9
PLABEL10: PLABEL10
PLABEL11: PLABEL11
PLABEL12: PLABEL12
U$2, U$7: SYMBOL_PLUS
U$4, U$5: SYMBOL_MINUS
U$8: PCBFEAT-REV-040
U$29: ADAFRUIT_3.5MM
U$31, U$32: STEMMAQT

## KiCad design CAD Files/sensor fab/volt div breakout board/Adafruit Stemma QT 5 Port Hub.kicad_pcb

Parts:
CONN1, CONN2, CONN3, CONN4, CONN5: STEMMA_I2C_QTRA; JST_SH4_RA
D1: GREEN; CHIPLED_0603_NOOUTLINE
FID3, FID4: FIDUCIAL_1MM
JP1, JP4: HEADER-1X476MIL; 1X04_ROUND_76
R1: 10K; 0603-NO
U$1, U$17, U$19, U$21: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
GND: CONN1.1 (GND), CONN1.MT1 (MT), CONN1.MT2 (MT), CONN2.1 (GND), CONN2.MT1 (MT), CONN2.MT2 (MT), CONN3.1 (GND), CONN3.MT1 (MT), CONN3.MT2 (MT), CONN4.1 (GND), CONN4.MT1 (MT), CONN4.MT2 (MT), CONN5.1 (GND), CONN5.MT1 (MT), CONN5.MT2 (MT), D1.C, JP1.2, JP4.2
unnamed: D1.A, R1.2
SCL: CONN1.4 (SCL), CONN2.4 (SCL), CONN3.4 (SCL), CONN4.4 (SCL), CONN5.4 (SCL), JP1.3, JP4.3
SDA: CONN1.3 (SDA), CONN2.3 (SDA), CONN3.3 (SDA), CONN4.3 (SDA), CONN5.3 (SDA), JP1.4, JP4.4
VCC: CONN1.2 (V+), CONN2.2 (V+), CONN3.2 (V+), CONN4.2 (V+), CONN5.2 (V+), JP1.1, JP4.1, R1.1

Notes on the sheet:
ON LED

Board: 2 copper layers, 25.4 x 17.8 mm, 20 parts (3 on the bottom side), 5 nets.

Other parts of the board:
U$2, U$3: ADAFRUIT_3.5MM
U$25: PCBFEAT-REV-040
U$30, U$31: STEMMAQT

## Commit log (part)

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2024-10-29 Added CAD and Blender Files
    Added CAD and Blender Files
2024-11-04 CAD Files Added
    CAD Files Added
2024-11-14 Phil Code Add
    Phil Code Add
2024-11-14 Added single loop strain abs sensor
    Added single loop strain abs sensor
2024-11-14 added files
2024-12-12 New Files
    New Files
2024-12-18 new servo code
2024-12-18 Code and Data Added
2024-12-19 new code and data
2024-12-19 updated presentation from 12/19/24
2025-01-07 Consolidated Files and Folders
    Consolidated Files and Folders
2025-01-09 added code
2025-01-13 Organized CAD folders and added images
2025-01-13 added analysis and daq folder and files
2025-01-14 Added Folders
2025-01-14 added angle testing image
2025-01-15 added to read me
2025-01-16 added images to read me
2025-01-16 adding xls sheet download to keep paired with the repo
2025-01-16 ipynb with examples of new refactored analysis.py code
2025-01-16 preeya updates during 1/15/25 code review -- cleaning up load_data method, refactoring plotting / accuracy, adding data scatter for visualizing temporal changes
2025-01-16 config file with path info
2025-01-21 added to analysis
2025-01-22 added to bender class and analysis code
2025-01-22 changed master csv file
2025-01-22 added kinematic presentation folder
2025-01-23 updated analysis files
2025-01-23 Updated Code
2025-01-23 updated analysis code
2025-01-24 added DS_all and errorbars to Toms plot
2025-01-24 added old Bender class so toms old code is still runnable
2025-01-24 Updated analysis comparison
2025-02-04 new reapplication data
2025-02-06 new reapplication data and analysis
2025-02-11 Sensor Fab and Mis Data
    Collected new misalignment data on two additional samples. Also created cad files and png image for sensor fabrication image for future paper
2025-02-13 added bender_class methods
2025-02-18 updated bender_class and added analysis code
    updated bender_class , added analysis code, and created prelim fig 1
2025-02-27 updated error analysis
2025-02-27 updated analysis
2025-03-05 added CAD files, analysis, and fig 1
2025-03-08 updates fab image renderings
2025-03-13 added fig 1 images
2025-03-14 minor changes/comments. Only main change was moving self.all_accuracies out of the itneration loop
2025-03-14 add notebook that checks erorr analysis.ipynb
2025-03-14 added new tab for PK data check of fig 1
2025-03-14 saved notebook
2025-03-17 preeya reconstruction of fig 1 plots
2025-03-17 added absolute error metrics to places where model is trained and tested so dont need specific fcns to do this
2025-03-17 general cleanup
2025-03-17 ensured entirety of test data is evaluated, added analysis to get min_angle_100 for each iteration, and added method to plot mean and std of list as part of plotting bars
2025-03-17 data updates to PK tab
2025-03-17 updates to PK ipynb
2025-03-18 changed some csv file names and made sure Preeya code worked on my end
    corrected some csv file names to consistent with rest of filenames.
2025-03-18 conducted ~ 10 retests wtih 16 ADC and 8x amp
2025-03-20 New voltage divider circuit and retests
2025-04-09 added data, daq code, and modified analysis
    added data, daq code, and modified analysis delta norm to take into account negative and pos adc values
2025-04-09 updated 4_9_25 presentation
2025-04-11 Python DAQ, new CSV files, and Analsys.py change
    Added a GUI to the python daq so that user can enter sample info. Also, csv auto saved in correct folder. Changed analysis accuracy method so that instead in incremeting angle of min accuracy by 1, i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
2025-04-15 Acquired More Data, Changed analysis.py to include quadratic fitting
2025-04-18 1 sample of reapplicaton and misalignment with Velcro...updated presentation
2025-04-18 collected reapplication and misalignment data with velcro
2025-04-22 finished testing misalignment, reapplication, and length data. All code updated
2025-04-25 updated circuit
2025-04-29 improved organization of datafile,
2025-04-30 Updated data spreadsheet and reapplication analysis code
2025-04-30 updated datasheet for clarity one last time
2025-05-05 new data acquired and new arduino daq
2025-05-12 new data
2025-05-14 circuit design for camera setup and new reapp analysis
2025-05-23 new data acquired for model testing
2025-06-06 new data and data vs model analysis
2025-06-06 updated model analysis notebook
2025-06-06 updated model fitting analysis
2025-06-12 added arduino code for mcp3564 adc
2025-06-13 updated adc code for MCP3564
2025-07-02 new ad7124 arduino code and stereo cam code
2025-07-18 new camera, DAQ, and adc code!
2025-08-13 added camera analysis code
2025-08-13 new dlc class methods
2025-08-14 completed camera_encoder_cal code
2025-08-14 completed camera_encoder_cal notebook
2025-08-15 updated figures
2025-08-18 updated figures and analysis code
2025-08-22 updated analysis.py and camera jupyter notebook
2025-08-25 modified camera notebook
2025-08-27 code to analyze mediapipe data
2025-08-29 added MediaPipe and HaMeR code
2025-09-02 MATLAB calibration worked
2025-09-05 strain vs encoder code
    added notebook code for calibration of strain sensor on autobender using rpi breakout board
2025-09-10 more changes
2025-09-16 added BallBearingData Class for notebook
2025-09-21 wrote code for tom marble analysis
2025-09-21 tom marble updated
2025-09-22 updated tom marble analysis
2025-09-23 updated tom marble notebook
2025-09-23 updated csv folder for Phil
2025-09-29 added signed angle calc, angle error calc, summary image
2025-09-29 added signed option for angle_from_vectors()
2025-09-29 added sign/unsigned knob
2025-09-29 updated analysis.py and tom marble
2025-09-29 updated analysis.py, matched timestamps
2025-10-01 updated analysis and notebooks
2025-10-01 added signed option to angle calc function
2025-10-01 updated tom_marble notebook
2025-10-01 analysis and tom marble updated
2025-10-01 updated analysis and tom_marble
2025-10-01 updated analysis.py
2025-10-02 Phil changes before lab mtg pres
2025-10-08 updated analysis and tom marble notebook
2025-10-09 angle comparisons between DLC 3D
2025-10-09 signed angles_from_vectors func
2025-11-04 updates
    1. updates to fig 1
    2. updates to analysis.py
    3. updates to tom_marble notebook code
2025-11-10 updates to analysis
2025-11-11 updated analysis and adc and imu plotting
2025-11-11 added imu_ciode for plotting
2025-11-12 updated imu and tom marble code.
2025-11-13 created new ADC_CAM class and ADC am notebook
2025-11-14 adc error analysis complete
2025-11-15 adc analysis updated
2025-11-15 updated adc_vs_cam notebook
2025-11-17 updated adc_cam analysis
2025-11-25 updated adc and imu classes and notebooks
2025-11-25 created method for paper fig error bars
2025-11-25 summary plots updated
2025-11-26 created single code for fig 1 nice
2025-11-26 updated fig 1
2025-12-02 updated imu figure code
2025-12-02 updated code for adc cam figure
2025-12-03 added calibration plot to fig 2
2025-12-03 updated code for plotting figure 2
2025-12-08 fig 1 iteration
2025-12-09 fig 2 iteration
2025-12-09 fig 3 iteration
2025-12-11 fig 2 and 3 iteration
2025-12-11 fig 2 suppress warnings
2025-12-12 fig 2 iteration and p4 supp figure made
2026-01-28 figure label iterations
2026-01-28 fig iter
2026-01-29 more code, updated circuits
2026-01-29 new code and circuits diagrams
2026-01-29 reloaded checkpoint files
2026-01-29 fig2 new
2026-01-29 IMU_vs_cam notebook
2026-02-03 added abduction anal code and rename abd csv file name
2026-02-06 ignore
2026-02-09 .ds -ignore
2026-02-09 supp fig made -ignore
2026-03-02 updated Fig 4 plot and imu analysis
2026-03-02 updated imu_vs_cam analysis and fig code
2026-03-02 fig 4 update
2026-03-06 plotted timestamp on x axis in sec
    legend displays correct total elapsed time
2026-03-06 correct time from timestamps plotted
2026-03-09 add .gitignore
2026-03-09 Ignore Python cache files and .DS_Store
2026-03-09 adding global gitignore
2026-03-09 added long term analysis code
2026-03-09 gitignore long_term_wear_data
2026-03-09 flex/ext from long term wear
2026-03-09 naive ADC -> degree
2026-03-10 adding ad_ab analysis
2026-03-16 gitignore update
2026-04-03 added content to adc code
2026-04-17 long wear figs
2026-04-27 long plot updates
2026-04-27 upload ad/ab file
2026-05-01 ad_ab supp figure updates
2026-06-16 Add user comfort analysis folder
2026-06-16 Update wear analysis plots and data
2026-06-16 Ignore macOS system files
2026-06-16 Ignore large raw wear data files
